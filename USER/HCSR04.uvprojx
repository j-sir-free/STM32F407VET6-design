# Keil uVision project HCSR04.uvprojx, settings and files
target hcsr04 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HCSR04 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\HC-SR04;..\HARDWARE\SEG_8;..\HARDWARE\TIMER;..\HARDWARE\CHECK;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\font;..\SYSTEM\usart;..\FWLIB\src;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\BLE;..\HARDWARE\USART2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARD
    ../HARDWARE/HC-SR04/: hcsr04.c
    ../HARDWARE/SEG_8/: SEG_8.c
    ../HARDWARE/TIMER/: TIMER.c
    ../HARDWARE/font/: font.c
    ../HARDWARE/CHECK/: CHECK.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/BLE/: ble.c
    ../HARDWARE/USART2/: usart2.c
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
